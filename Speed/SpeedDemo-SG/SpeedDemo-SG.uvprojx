# Keil uVision project SpeedDemo-SG.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MKL25Z128xxx4 NXP
  pack: Keil.Kinetis_KLxx_DFP.1.13.0
  cpu: IRAM(0x1FFFF000,0x00004000) IROM(0x00000000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: SpeedDemo-SG
  AfterMake: C:\Users\Alex\Documents\Teaching\ESO\ESO-2018\Code\ESO-18\Speed\SpeedDemo-SG\Scripts\update_regions_MDK.bat !L
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: --fpmode=fast
  c include: .\Include;.\Source\LCD;.\Source\Profiler
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  group Source
    ./Source/: debug.c delay.c I2C.c LEDs.c main.c MMA8451.c timers.c CMAN_coords.c geometry.c
  group Profiler
    ./Source/Profiler/: PIT.c profile.c region.c
  group LCD
    ./Source/LCD/: LCD_graphics.c LCD_text.c lucida_8x13.c lucida_12x19.c lucida_20x31.c ST7789.c touchscreen.c
software components: CMSIS:CORE 5.0.2, Device:Startup 2.5.0
